## prj.conf
```kconfig
CONFIG_TEST_LIB=y
```

## src/main.c
```c
#include <test_lib/test_lib.h>

int main(void) {
  test_lib_hello("test-lib");

  return 0;
}
```
